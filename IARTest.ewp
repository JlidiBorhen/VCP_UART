# IAR project IARTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Include; ..\Utilities\STM32F4-Discovery; ..\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; usb_conf; usb_lib\cdc; usb_lib\otg; usb_lib\core
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IARTest.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: delay.c delay.h main.c
  group inc
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ../Libraries/CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h
    ./: stm32f4xx_conf.h
  group src
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group usb_conf
    usb_conf/: usb_bsp.c usb_bsp.h usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
  group usb_lib/cdc
    usb_lib/cdc/: usbd_cdc_core.c usbd_cdc_core.h usbd_cdc_vcp.c usbd_cdc_vcp.h
  group usb_lib/core
    usb_lib/core/: usbd_core.c usbd_core.h usbd_def.h usbd_ioreq.c usbd_ioreq.h usbd_req.c usbd_req.h usbd_usr.h
  group usb_lib/otg
    usb_lib/otg/: usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h
